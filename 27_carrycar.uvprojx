# Keil uVision project 27_carrycar.uvprojx, settings and files
target 27_carrycar (6070000::V6.7::.\ARMCLANG)
  device: STM32G491VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001BFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: 27_carrycar +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G491xx
  c include: Core/Inc;Drivers/STM32G4xx_HAL_Driver/Inc;Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;Drivers/CMSIS/Device/ST/STM32G4xx/Include;Drivers/CMSIS/Include;Hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Hardware
    Hardware/: chassis.c chassis.h chassis_config.h chassis_motion.c chassis_motion.h heading_control.c heading_control.h hwt101_uart.c hwt101_uart.h mecanum_kinematics.c mecanum_kinematics.h hmi_protocol.h hmi_protocol.c map_graph.h map_graph.c path_planner.h path_planner.c hmi_display.h hmi_display.c can.h can.c emm_v5.h emm_v5.c vofa_debug.c emm_adapter.h emm_adapter.c hwt101_compat.c path_executor.c navigation.c hmi_navigation.c servo.c manipulator.c k230.c qr_scanner.c app_uart.c edge_motion.c robot_app.c
    ./Hardware/: vofa_debug.h robot_config.h servo.h manipulator.h manipulator_action.h manipulator_action.c k230.h material_load_task.c material_load_task.h zone_task.c zone_task.h k230_align.c k230_align.h
    Core/Src/: tim.c
  group Application/User/Core
    Core/Src/: main.c gpio.c fdcan.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.2.0
